<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\Source\APP\app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\APP\app_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\APP\app_isr.s90</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\APP\app_vect.s90</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\APP\includes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\APP\os_cfg.h</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\Source\BSP\avr_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\avr_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\bsp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\data_type_convert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\data_type_convert.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\fish_data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\fish_data.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\lz_fish.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\lz_fish.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\MPU6050.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\MPU6050.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\twi_master.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\BSP\twi_master.h</name>
    </file>
  </group>
  <group>
    <name>uC/OS-II</name>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_flag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_mbox.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_mutex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_q.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_sem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_time.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\os_tmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Source\ucos_ii.h</name>
    </file>
  </group>
  <group>
    <name>uC/OS-II Port</name>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Ports\os_cpu.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Ports\os_cpu_a.s90</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Ports\os_cpu_c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\uCOS-II\Ports\os_dbg.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\Readme.md</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Save.txt</name>
  </file>
</project>


