# IAR project SmartTuna.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $PROJ_DIR$; Source\BSP; Source\APP; Source\uCOS-II\Source; Source\uCOS-II\Ports
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkm128s.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  group (top)
    ./: Readme.md Save.txt
  group App
    Source/APP/: app.c app_cfg.h app_isr.s90 app_vect.s90 includes.h os_cfg.h
  group BSP
    Source/BSP/: avr_uart.c avr_uart.h bsp.c bsp.h data_type_convert.c data_type_convert.h fish_data.c fish_data.h lz_fish.c lz_fish.h MPU6050.c MPU6050.h twi_master.c twi_master.h
  group uC/OS-II
    Source/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uC/OS-II Port
    Source/uCOS-II/Ports/: os_cpu.h os_cpu_a.s90 os_cpu_c.c os_dbg.c
